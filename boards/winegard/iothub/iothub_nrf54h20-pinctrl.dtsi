/*
 * Copyright (c) 2024 Nordic Semiconductor ASA
 *
 * SPDX-License-Identifier: Apache-2.0
 */

&pinctrl {
	//Set up uart135 for gps uart for now to avoid conflict. 
	//may change later
	/omit-if-no-ref/ uart135_default: uart135_default {
		group1 {
			psels = <NRF_PSEL(UART_TX, 0, 5)>,
		};

		group3 {
			bias-pull-up;
			psels = <NRF_PSEL(UART_RX, 0, 4)>,
		};
	};

	/omit-if-no-ref/ uart135_sleep: uart135_sleep {
		group1 {
			low-power-enable;
			psels = <NRF_PSEL(UART_TX, 0, 5)>,
				<NRF_PSEL(UART_RX, 0, 4)>,
		};
	};

	/omit-if-no-ref/ uart136_default: uart136_default {
		group1 {
			psels = <NRF_PSEL(UART_TX, 0, 11)>,
		};

		group3 {
			bias-pull-up;
			psels = <NRF_PSEL(UART_RX, 0, 10)>,
		};
	};

	/omit-if-no-ref/ uart136_sleep: uart136_sleep {
		group1 {
			low-power-enable;
			psels = <NRF_PSEL(UART_TX, 0, 11)>,
				<NRF_PSEL(UART_RX, 0, 10)>,
		};
	};

	/omit-if-no-ref/ exmif_default: exmif_default {
		group1 {
			psels = <NRF_PSEL(EXMIF_CK, 6, 0)>,
				<NRF_PSEL(EXMIF_CS0, 6, 3)>,
				<NRF_PSEL(EXMIF_RWDS, 6, 2)>,
				<NRF_PSEL(EXMIF_DQ0, 6, 7)>,
				<NRF_PSEL(EXMIF_DQ1, 6, 5)>,
				<NRF_PSEL(EXMIF_DQ2, 6, 10)>,
				<NRF_PSEL(EXMIF_DQ3, 6, 9)>,
				<NRF_PSEL(EXMIF_DQ4, 6, 11)>,
				<NRF_PSEL(EXMIF_DQ5, 6, 8)>,
				<NRF_PSEL(EXMIF_DQ6, 6, 6)>,
				<NRF_PSEL(EXMIF_DQ7, 6, 4)>;
			nordic,drive-mode = <NRF_DRIVE_H0H1>;
		};
	};

	/omit-if-no-ref/ exmif_sleep: exmif_sleep {
		group1 {
			low-power-enable;
			psels = <NRF_PSEL(EXMIF_CK, 6, 0)>,
				<NRF_PSEL(EXMIF_CS0, 6, 3)>,
				<NRF_PSEL(EXMIF_RWDS, 6, 2)>,
				<NRF_PSEL(EXMIF_DQ0, 6, 7)>,
				<NRF_PSEL(EXMIF_DQ1, 6, 5)>,
				<NRF_PSEL(EXMIF_DQ2, 6, 10)>,
				<NRF_PSEL(EXMIF_DQ3, 6, 9)>,
				<NRF_PSEL(EXMIF_DQ4, 6, 11)>,
				<NRF_PSEL(EXMIF_DQ5, 6, 8)>,
				<NRF_PSEL(EXMIF_DQ6, 6, 6)>,
				<NRF_PSEL(EXMIF_DQ7, 6, 4)>;
		};
	};

	/omit-if-no-ref/ can120_default: can120_default {
		group1 {
			psels = <NRF_PSEL(CAN_RX, 2, 8)>,
				<NRF_PSEL(CAN_TX, 2, 9)>;
		};
	};

	/omit-if-no-ref/ grtc_sleep: grtc_sleep {
		group1 {
			psels = <NRF_PSEL(GRTC_CLKOUT_FAST, 1, 8)>,
				<NRF_PSEL(GRTC_CLKOUT_32K, 0, 1)>;
			low-power-enable;
		};
	};

	/omit-if-no-ref/ spi130_default: spi130_default {
		group1 {
			psels = <NRF_PSEL(SPIM_SCK, 2, 3)>,
				<NRF_PSEL(SPIM_MISO, 2, 5)>,
				<NRF_PSEL(SPIM_MOSI, 2, 6)>;
		};
	};

	/omit-if-no-ref/ spi130_sleep: spi130_sleep {
		group1 {
			psels = <NRF_PSEL(SPIM_SCK, 2, 3)>,
				<NRF_PSEL(SPIM_MISO, 2, 5)>,
				<NRF_PSEL(SPIM_MOSI, 2, 6)>;
			low-power-enable;
		};
	};

};
